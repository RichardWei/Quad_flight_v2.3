# Keil uVision project STM32_FK.uvproj, settings and files
target weizhou_filght (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_FK +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\DRIVERS\inc;..\CPU;..\APP\LED;..\APP\INIT;..\APP\ADXL345;..\APP\L3G4200;..\APP\IIC;..\APP\IMU;..\APP\Send_Data;..\APP\DMA;..\APP\IIC;..\APP\HMC5883
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/INIT/: INIT.c
    ../APP/LED/: LED.c
    ../APP/ADXL345/: ADXL345.c
    ../APP/L3G4200/: L3G4200.c
    ../APP/IIC/: IIC.c
    ../APP/IMU/: IMU.c
    ../APP/Send_Data/: SendData.c
    ../APP/DMA/: DMA.c
    ../APP/HMC5883/: HMC5883.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group DRIVERS
    ../DRIVERS/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CPU
    ../CPU/: core_cm3.c startup_stm32f10x_hd.s
